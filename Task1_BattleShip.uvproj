# Keil uVision project Task1_BattleShip.uvproj, settings and files
target EEET2481_Tutorial_7_EADC (6220000::V6.22::ARMCLANG)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x9FFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: EEET2481_Tutorial_7_EADC
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 v6Lang=1 v6LangP=3
  c include: .\Library\Device\Nuvoton\M480\Include;.\Library\StdDriver\inc;.\Library\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./Library/Device/Nuvoton/M480/Source/: system_M480.c
    ./Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group Library
    ./Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c
  group User
    ./: main.c
